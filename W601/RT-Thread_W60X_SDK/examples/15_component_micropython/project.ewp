# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __inline=inline; __inline__=inline; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; WM_W600; __inline=inline; __inline__=inline
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: packages\tinycrypt-v1.0.0\include; ..\..\drivers; ..\..\rt-thread\components\net\netdev\include; ..\..\rt-thread\components\libc\compilers\common; ports\fal; ..\..\rt-thread\components\net\sal_socket\include\dfs_net; packages\fal-v0.3.0\inc; ..\..\libraries\WM_Libraries\Platform\Boot\gcc; ..\..\rt-thread\components\libc\compilers\dlib; ..\..\libraries\WM_Libraries\Include\WiFi; ..\..\rt-thread\components\dfs\filesystems\elmfat; ..\..\rt-thread\components\net\lwip_dhcpd; ..\..\libraries\WM_Libraries\Platform\Common\crypto\math; ..\..\rt-thread\components\net\sal_socket\include\dfs_net\sys_select; ..\..\rt-thread\components\drivers\include; ..\..\libraries\WM_Libraries\Platform\Common\crypto\symmetric; ..\..\rt-thread\components\utilities\ulog; ..\..\rt-thread\components\net\lwip-2.0.2\src; ..\..\libraries\WM_Libraries\Platform\Common\Params; packages\micropython-v1.10.1\port\modules\machine; ..\..\rt-thread\include; .; ..\..\libraries\WM_Libraries\Include\Driver; ..\..\libraries\WM_Libraries\Include\Platform; ..\..\libraries\WM_Libraries\Include; ..\..\libraries\WM_Libraries\Include\OS; packages\netutils-v1.1.0\ntp; packages\adbd-v1.1.1\inc; ..\..\rt-thread\components\net\sal_socket\include\socket; ..\..\rt-thread\components\net\sal_socket\include; ..\..\rt-thread\components\net\lwip-2.0.2\src\include; ..\..\rt-thread\components\drivers\spi\sfud\inc; ..\..\rt-thread\components\net\lwip-2.0.2\src\include\ipv4; ..\..\libraries\WM_Libraries\Platform\Inc; packages\micropython-v1.10.1\port; ..\..\rt-thread\components\dfs\include; ..\..\rt-thread\components\net\sal_socket\impl; applications; packages\cJSON-v1.0.2; ..\..\rt-thread\libcpu\arm\cortex-m3; ..\..\rt-thread\components\finsh; ..\..\rt-thread\components\drivers\spi; ..\..\rt-thread\components\drivers\wlan; packages\micropython-v1.10.1; ..\..\rt-thread\components\net\sal_socket\include\socket\sys_socket; ..\..\libraries\WM_Libraries\Platform\Common\crypto\digest; ..\..\libraries\WM_Libraries\Platform\Drivers\spi; ..\..\libraries\WM_Libraries; ..\..\rt-thread\components\net\lwip-2.0.2\src\arch\include; packages\adbd-v1.1.1\services; ..\..\rt-thread\components\dfs\filesystems\devfs; ..\..\rt-thread\libcpu\arm\common; ..\..\rt-thread\components\net\lwip-2.0.2\src\include\netif; packages\micropython-v1.10.1\port\modules; ..\..\libraries\WM_Libraries\Platform\Common\crypto
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rtthread.bin
  postbuild: cmd /c "makeimg.bat"
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: ..\..\drivers\linker_scripts\link.icf
  ILINK.IlinkAdditionalLibs: ..\..\libraries\WM_Libraries\Lib\Wlan\libwlan_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group Kernel
    ../../rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group adb
    packages/adbd-v1.1.1/core/: adb.c adb_pque.c adb_service.c adbusb.c transport.c transport_socket.c transport_usb.c
    packages/adbd-v1.1.1/services/: shell_service.c file_sync_service.c file_exmod.c file_sync_mod.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group fal
    packages/fal-v0.3.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_port.c fal_flash_sfud_port.c
  group MicroPython
    packages/micropython-v1.10.1/py/: argcheck.c asmarm.c asmbase.c asmthumb.c asmx64.c asmx86.c asmxtensa.c bc.c binary.c builtinevex.c builtinhelp.c builtinimport.c compile.c emitbc.c emitcommon.c emitglue.c emitinlinethumb.c emitinlinextensa.c emitnarm.c emitnative.c emitnthumb.c emitnx64.c emitnx86.c emitnxtensa.c formatfloat.c frozenmod.c gc.c lexer.c malloc.c map.c modarray.c modbuiltins.c modcmath.c modcollections.c modgc.c modio.c modmath.c modmicropython.c modstruct.c modsys.c modthread.c moduerrno.c mpprint.c mpstate.c mpy_scheduler.c mpz.c nativeglue.c nlr.c nlrsetjmp.c nlrthumb.c nlrx64.c nlrx86.c nlrxtensa.c obj.c objarray.c objattrtuple.c objbool.c objboundmeth.c objcell.c objclosure.c objcomplex.c objdeque.c objdict.c objenumerate.c objexcept.c objfilter.c objfloat.c objfun.c objgenerator.c objgetitemiter.c objint.c objint_longlong.c objint_mpz.c objlist.c objmap.c objmodule.c objnamedtuple.c objnone.c objobject.c objpolyiter.c objproperty.c objrange.c objreversed.c objset.c objsingleton.c objslice.c objstr.c objstringio.c objstrunicode.c objtuple.c objtype.c objzip.c opmethods.c parse.c parsenum.c parsenumbase.c persistentcode.c pystack.c qstr.c reader.c repl.c runtime.c runtime_utils.c scope.c sequence.c showbc.c smallint.c stackctrl.c stream.c unicode.c vm.c vstr.c warning.c
    packages/micropython-v1.10.1/lib/mp-readline/: readline.c
    packages/micropython-v1.10.1/lib/utils/: interrupt_char.c mpirq.c printf.c pyexec.c stdout_helpers.c sys_stdio_mphal.c
    packages/micropython-v1.10.1/extmod/: machine_i2c.c machine_mem.c machine_pinbase.c machine_pulse.c machine_signal.c machine_spi.c modbtree.c modframebuf.c modonewire.c modubinascii.c moducryptolib.c moductypes.c moduhashlib.c moduheapq.c modujson.c modurandom.c modure.c moduselect.c modussl_axtls.c modussl_mbedtls.c modutimeq.c moduwebsocket.c moduzlib.c modwebrepl.c modwebsocket.c uos_dupterm.c utime_mphal.c vfs.c vfs_fat.c vfs_fat_diskio.c vfs_fat_file.c vfs_posix.c vfs_posix_file.c vfs_reader.c virtpin.c
    packages/micropython-v1.10.1/port/: frozen_mpy.c gccollect.c mpgetcharport.c mphalport.c mpputsnport.c mpthreadport.c mpy_main.c
    packages/micropython-v1.10.1/port/modules/: modffi.c modfile.c modnetwork.c modnetwork_wlan.c modpyb.c modrtthread.c moduos.c moduos_file.c modusocket.c modutils.c modutime.c
    packages/micropython-v1.10.1/port/modules/machine/: machine_adc.c machine_hw_i2c.c machine_hw_spi.c machine_lcd.c machine_pin.c machine_pwm.c machine_rtc.c machine_timer.c machine_uart.c machine_wdt.c modmachine.c
    packages/micropython-v1.10.1/lib/netutils/: netutils.c
    packages/micropython-v1.10.1/lib/timeutils/: timeutils.c
    packages/micropython-v1.10.1/drivers/bus/: softqspi.c softspi.c
    packages/micropython-v1.10.1/port/native/: easyflash_module.c native_module.c
  group NetUtils
    packages/netutils-v1.1.0/ntp/: ntp.c
  group TinyCrypt
    packages/tinycrypt-v1.0.0/src/: tiny_aes.c tiny_base64.c tiny_md5.c tiny_sha1.c tiny_sha2.c
  group cpu
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group Filesystem
    ../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ../../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../rt-thread/components/drivers/hwtimer/: hwtimer.c
    ../../rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../rt-thread/components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../rt-thread/components/drivers/rtc/: rtc.c
    ../../rt-thread/components/drivers/serial/: serial.c
    ../../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread/components/drivers/watchdog/: watchdog.c
    ../../rt-thread/components/drivers/wlan/: wlan_dev.c wlan_mgnt.c wlan_cmd.c wlan_prot.c wlan_lwip.c wlan_cfg.c wlan_workqueue.c
  group finsh
    ../../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../rt-thread/components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group lwIP
    ../../rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
    ../../rt-thread/components/net/lwip_dhcpd/: dhcp_server_raw.c
  group netdev
    ../../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../rt-thread/components/net/sal_socket/src/: sal_socket.c
    ../../rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    ../../rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group Utilities
    ../../rt-thread/components/utilities/ulog/: ulog.c
    ../../rt-thread/components/utilities/ulog/backend/: console_be.c
  group Libraries
    ../../libraries/WM_Libraries/Platform/Drivers/cpu/: wm_cpu.c
    ../../libraries/WM_Libraries/Platform/Drivers/gpio/: wm_gpio.c wm_gpio_afsel.c
    ../../libraries/WM_Libraries/Platform/Drivers/io/: wm_io.c
    ../../libraries/WM_Libraries/Platform/Drivers/irq/: wm_irq.c
    ../../libraries/WM_Libraries/Platform/Drivers/efuse/: wm_efuse.c
    ../../libraries/WM_Libraries/Platform/Drivers/internalflash/: wm_internal_fls.c
    ../../libraries/WM_Libraries/Platform/Drivers/spi/: wm_hostspi.c
    ../../libraries/WM_Libraries/Platform/Drivers/flash/: wm_fls.c wm_fls_gd25qxx.c
    ../../libraries/WM_Libraries/Platform/Drivers/dma/: wm_dma.c
    ../../libraries/WM_Libraries/Platform/Drivers/timer/: wm_timer.c
    ../../libraries/WM_Libraries/Platform/Drivers/watchdog/: wm_watchdog.c
    ../../libraries/WM_Libraries/Platform/Drivers/i2c/: wm_i2c.c
    ../../libraries/WM_Libraries/Platform/Drivers/pwm/: wm_pwm.c
    ../../libraries/WM_Libraries/Platform/Drivers/adc/: wm_adc.c
    ../../libraries/WM_Libraries/Platform/Drivers/pmu/: wm_pmu.c
    ../../libraries/WM_Libraries/Platform/Drivers/rtc/: wm_rtc.c
    ../../libraries/WM_Libraries/Platform/Common/Params/: wm_param.c
    ../../libraries/WM_Libraries/Platform/Common/fwup/: wm_fwup.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/: wm_crypto_hard.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/digest/: wm_crypto_hmac.c wm_crypto_md2.c wm_crypto_md4.c sha224.c sha384.c wm_crypto_sha512.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/keyformat/: asn1.c wm_crypto_base64.c wm_crypto_x509.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/math/: pstm_mul_comba.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/prng/: prng.c yarrow.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/pubkey/: dh.c ecc.c pkcs.c pubkey.c wm_crypto_rsa.c
    ../../libraries/WM_Libraries/Platform/Common/crypto/symmetric/: aesGCM.c des3.c idea.c rc2.c seed.c
    ../../libraries/WM_Libraries/rtthread/: rtthread_patch.c
    ../../libraries/WM_Libraries/rtthread/utils/: utils.c
    ../../libraries/WM_Libraries/rtthread/startup/iar/: startup_venus.S
    ../../libraries/WM_Libraries/Platform/Boot/iar/: misc.c
  group Drivers
    ../../drivers/: board.c drv_uart.c drv_flash.c pin_map.c drv_adc.c drv_wifi.c drv_pin.c drv_hw_timer.c drv_soft_i2c.c drv_spi.c drv_spiflash.c drv_lcd.c drv_pwm.c drv_rtc.c drv_wdt.c
